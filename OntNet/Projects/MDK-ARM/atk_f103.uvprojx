# Keil uVision project atk_f103.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\EXPAND\OneNet\device\inc;..\..\Drivers\EXPAND\OneNet\MQTT;..\..\Drivers\EXPAND\OneNet\onenet\inc;..\..\Drivers\EXPAND\OneNet\cJSON;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: LED.c
    ../../Drivers/BSP/KEY/: KEY.c
    ../../Drivers/BSP/WDG/: wdg.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/TIMER/: btim.c
  group Readme
    ../../: readme.txt
  group Expand
    ../../Drivers/EXPAND/OneNet/device/src/: esp8266.c
    ../../Drivers/EXPAND/OneNet/MQTT/: MqttKit.c
    ../../Drivers/EXPAND/OneNet/onenet/src/: base64.c hmac_sha1.c onenet.c
    ../../Drivers/EXPAND/OneNet/cJSON/: cJSON.c
